# Keil uVision project ADS1256.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: ADS1256 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\ADS1256;..\user
  group main
    ../user/: main.c
  group ads1256
    ../ADS1256/: ADS1256.C
